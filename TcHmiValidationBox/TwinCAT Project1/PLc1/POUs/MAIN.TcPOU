PROGRAM MAIN
VAR
	nCount : INT;
	sSampleString : STRING;
	nTest : REAL;
	sPassword : STRING;
END_VAR

END_PROGRAM
